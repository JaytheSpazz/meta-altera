LINUX_VERSION = "socfpga_fm6_emulator_v6"

SRCREV = "3bd9881838eed0392668376fc81c33c360d104d4"

include linux-altera.inc


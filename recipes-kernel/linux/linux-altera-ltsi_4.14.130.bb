LINUX_VERSION = "4.14.130"
LINUX_VERSION_SUFFIX = "-ltsi_v2"

SRCREV = "d05b2e5d32d094cba882a52bf7ab4ac8a0d6a9e2"

include linux-altera.inc


LINUX_VERSION = "4.14.73"
LINUX_VERSION_SUFFIX = "-ltsi"

SRCREV = "3f84072ea879f84543f4a61cd88bdc88b6927474"

include linux-altera.inc


LINUX_VERSION = "4.9.78"
LINUX_VERSION_SUFFIX = "-ltsi"

SRCREV = "bdf910b1939e45beef022239bda381a2b11a6337"

include linux-altera.inc


LINUX_VERSION = "4.9.51"
LINUX_VERSION_SUFFIX = "-ltsi"

SRCREV = "30d2c4532572237e82ce1c50e194bcc1bfaae9c6"

include linux-altera.inc

